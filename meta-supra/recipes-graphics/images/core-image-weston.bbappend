RDEPENDS:${PN}:remove = "psplash-raspberrypi"
RDEPENDS:${PN}:append = " psplash"
